#include "midiBufferParser.h"
#include "baseLib/os.h"

#include <cstdio>
#include <vector>

namespace
{
	using namespace synthLib;
	using Bytes = std::vector<uint8_t>;

	int g_failures = 0;

	// An event as its wire bytes: a sysex as is, anything else as long as its status byte says
	Bytes toBytes(const SMidiEvent& _ev)
	{
		if(!_ev.sysex.empty())
			return {_ev.sysex.begin(), _ev.sysex.end()};
		Bytes b{_ev.a, _ev.b, _ev.c};
		b.resize(MidiBufferParser::lengthFromStatusByte(_ev.a));
		return b;
	}

	void expect(const int _line, MidiBufferParser& _parser, const std::vector<Bytes>& _expected, const MidiEventSource _source = MidiEventSource::Device)
	{
		std::vector<SMidiEvent> events;
		_parser.getEvents(events);

		bool ok = events.size() == _expected.size();
		for(size_t i = 0; ok && i < events.size(); ++i)
			ok = toBytes(events[i]) == _expected[i] && events[i].source == _source;

		if(ok)
			return;

		++g_failures;
		std::printf("FAIL line %d, got:", _line);
		for(const auto& e : events)
		{
			std::printf(" [");
			for(const auto b : toBytes(e))
				std::printf(" %02x", b);
			std::printf(" ]");
		}
		std::printf("\n");
	}

	void parse(const int _line, const Bytes& _input, const std::vector<Bytes>& _expected)
	{
		MidiBufferParser parser(MidiEventSource::Device);
		parser.write(_input);
		expect(_line, parser, _expected);
	}
}

#define PARSE(...) parse(__LINE__, __VA_ARGS__)

int main()
{
	baseLib::disableErrorDialogs();

	// complete messages of every length
	PARSE({0x90, 0x3c, 0x64}, {{0x90, 0x3c, 0x64}});
	PARSE({0xc3, 0x05}, {{0xc3, 0x05}});
	PARSE({0xe0, 0x00, 0x40, 0xd1, 0x7f}, {{0xe0, 0x00, 0x40}, {0xd1, 0x7f}});
	PARSE({0xf3, 0x02, 0xf2, 0x10, 0x20, 0xf6}, {{0xf3, 0x02}, {0xf2, 0x10, 0x20}, {0xf6}});

	// an incomplete message is held until it completes
	{
		MidiBufferParser parser(MidiEventSource::Host);
		parser.write(0x90);
		parser.write(0x3c);
		expect(__LINE__, parser, {}, MidiEventSource::Host);
		parser.write(0x64);
		expect(__LINE__, parser, {{0x90, 0x3c, 0x64}}, MidiEventSource::Host);
	}

	// running status, three and two byte messages
	PARSE({0x90, 0x3c, 0x64, 0x3e, 0x64, 0x3c, 0x00}, {{0x90, 0x3c, 0x64}, {0x90, 0x3e, 0x64}, {0x90, 0x3c, 0x00}});
	PARSE({0xb0, 0x40, 0x00, 0x7b, 0x00}, {{0xb0, 0x40, 0x00}, {0xb0, 0x7b, 0x00}});
	PARSE({0xc0, 0x05, 0x06, 0x07}, {{0xc0, 0x05}, {0xc0, 0x06}, {0xc0, 0x07}});
	PARSE({0xd2, 0x10, 0x20}, {{0xd2, 0x10}, {0xd2, 0x20}});

	// running status carries over between writes
	{
		MidiBufferParser parser(MidiEventSource::Device);
		parser.write({0x91, 0x3c, 0x64});
		parser.write({0x3e});
		expect(__LINE__, parser, {{0x91, 0x3c, 0x64}});
		parser.write({0x64});
		expect(__LINE__, parser, {{0x91, 0x3e, 0x64}});
	}

	// a new status byte replaces the running status
	PARSE({0x90, 0x3c, 0x64, 0x80, 0x3c, 0x00, 0x3e, 0x00}, {{0x90, 0x3c, 0x64}, {0x80, 0x3c, 0x00}, {0x80, 0x3e, 0x00}});

	// data without a running status is dropped
	PARSE({0x3c, 0x64, 0x90, 0x3c, 0x64}, {{0x90, 0x3c, 0x64}});

	// system common clears the running status, its data does not continue a channel message
	PARSE({0x90, 0x3c, 0x64, 0xf3, 0x01, 0x3e, 0x64}, {{0x90, 0x3c, 0x64}, {0xf3, 0x01}});
	PARSE({0x90, 0x3c, 0x64, 0xf6, 0x3e, 0x64}, {{0x90, 0x3c, 0x64}, {0xf6}});

	// so does a sysex
	PARSE({0x90, 0x3c, 0x64, 0xf0, 0x7d, 0x01, 0xf7, 0x3e, 0x64}, {{0x90, 0x3c, 0x64}, {0xf0, 0x7d, 0x01, 0xf7}});

	// realtime leaves the running status alone, between messages and inside one
	PARSE({0x90, 0x3c, 0x64, 0xf8, 0x3e, 0x64}, {{0x90, 0x3c, 0x64}, {0xf8}, {0x90, 0x3e, 0x64}});
	PARSE({0x90, 0x3c, 0x64, 0x3e, 0xfe, 0x64}, {{0x90, 0x3c, 0x64}, {0xfe}, {0x90, 0x3e, 0x64}});
	PARSE({0x90, 0xf8, 0x3c, 0xfa, 0x64}, {{0xf8}, {0xfa}, {0x90, 0x3c, 0x64}});
	PARSE({0xc0, 0xf8, 0x05}, {{0xf8}, {0xc0, 0x05}});

	// a status byte ends an incomplete message
	PARSE({0x90, 0x3c, 0x80, 0x3c, 0x00}, {{0x80, 0x3c, 0x00}});
	PARSE({0xb0, 0x07, 0xc0, 0x05}, {{0xc0, 0x05}});
	PARSE({0x90, 0x3c, 0xf0, 0x01, 0xf7, 0x3e, 0x64, 0x90, 0x3c, 0x64}, {{0xf0, 0x01, 0xf7}, {0x90, 0x3c, 0x64}});

	// sysex: complete, split over writes, realtime inside, aborted by a status byte
	PARSE({0xf0, 0x41, 0x10, 0x42, 0xf7}, {{0xf0, 0x41, 0x10, 0x42, 0xf7}});
	{
		MidiBufferParser parser(MidiEventSource::Device);
		parser.write({0xf0, 0x41});
		expect(__LINE__, parser, {});
		parser.write({0x10, 0xf7});
		expect(__LINE__, parser, {{0xf0, 0x41, 0x10, 0xf7}});
	}
	PARSE({0xf0, 0x01, 0xf8, 0x02, 0xf7}, {{0xf8}, {0xf0, 0x01, 0x02, 0xf7}});
	PARSE({0xf0, 0x01, 0x02, 0x90, 0x3c, 0x64}, {{0xf0, 0x01, 0x02, 0xf7}, {0x90, 0x3c, 0x64}});
	PARSE({0xf0, 0x01, 0xf0, 0x02, 0xf7}, {{0xf0, 0x01, 0xf7}, {0xf0, 0x02, 0xf7}});

	// getEvents appends to events already there
	{
		MidiBufferParser parser(MidiEventSource::Device);
		parser.write({0x90, 0x3c, 0x64});
		std::vector<SMidiEvent> events{SMidiEvent(MidiEventSource::Device, 0xf8)};
		parser.getEvents(events);
		if(events.size() != 2 || toBytes(events[1]) != Bytes{0x90, 0x3c, 0x64})
		{
			++g_failures;
			std::printf("FAIL line %d\n", __LINE__);
		}
		expect(__LINE__, parser, {});
	}

	if(g_failures)
		std::printf("%d failure(s)\n", g_failures);
	else
		std::printf("midiBufferParser: all passed\n");
	return g_failures ? 1 : 0;
}
